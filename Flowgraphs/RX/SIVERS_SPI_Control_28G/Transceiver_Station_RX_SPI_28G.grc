options:
  parameters:
    author: Niklas Beckmann, Berk Acikgoez, Aleksandar Ichkov, Aron Schott
    copyright: iNETS - RWTH
    generate_options: qt_gui
    id: Transceiver_Station_RX_SPI_28G
    output_language: python
    title: Transceiver Station RX SPI 28G
  states: {}

blocks:
- name: bb_freq
  id: variable
  parameters:
    value: 35e6
  states: {}
- name: detector_threshold
  id: variable
  parameters:
    value: '60'
  states: {}
- name: header_format
  id: variable
  parameters:
    value: iNETS_PHYHeader.phy_header().formatter()
  states: {}
- name: init_rx_beam
  id: variable
  parameters:
    value: '0'
  states: {}
- name: init_tx_beam
  id: variable
  parameters:
    value: '11'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: max_mtu_size
  id: variable
  parameters:
    value: '800'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: partner_sta_code
  id: variable
  parameters:
    value: '11'
  states: {}
- name: rand_pad
  id: variable
  parameters:
    value: '20'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '111'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sta_code
  id: variable
  parameters:
    value: '12'
  states: {}
- name: sweeping
  id: variable_qtgui_chooser
  parameters:
    label: Choose Beam Sweeping Type
    label0: Fixed TX beam
    label1: Full TX beam sweep
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'True'
  states: {}
- name: time_per_angle_sec
  id: variable
  parameters:
    value: '1.7'
  states: {}
- name: usrp_rx_address
  id: variable
  parameters:
    comment: replace this with the IP address of your USRP
    value: '"addr=192.168.20.2"'
  states: {}
- name: usrp_rx_subdev_spec
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: iNETS_BeamManager_beamsteering_protocol_0
  id: iNETS_BeamManager_beamsteering_protocol
  parameters:
    beam_interval: '0.03'
    beamsteering_algorithm: '2'
    custom_beambook_suffix: '"_iNETS"'
    experimental_setup_comment: ''
    fixed_beam: init_rx_beam
    fixed_beam_backup_link_backup_beam_id: '21'
    fixed_beam_backup_link_beam_switch_message_retrans_no: '1'
    fixed_beam_backup_link_data_state_duration: '2.0'
    fixed_beam_backup_link_default_beam_id: '11'
    fixed_beam_backup_link_distance: '3.0'
    fixed_beam_backup_link_report_state_duration: '1.0'
    log_config_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Beamsteering_Protocol_events_configs/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Beamsteering_Protocol_persector/
    retrain_RSSI_threshold: '15'
    single_training_for_TX_and_RX: 'False'
    start_training: 'True'
    station_code: sta_code
    station_type: '1'
    sweeping: 'True'
    timeout_PLS: '0.2'
    timeout_PLS_timer_based: '0.03'
    timeout_PLS_timer_based_receive_SSW_frames: '0.03'
    timeout_RSSI_value_interval: '1.2'
    timeout_SLS: '0.2'
    timeout_SLS_timer_based: '0.24'
    timeout_SLS_timer_based_receive_SSW_frames: '0.065'
    timeout_history_search: '0.2'
    timeout_history_search_receive_SSW_frames: '0.8'
    timeout_iterative: '0.1'
    timeout_iterative_search_timer_based_receive_SSW_frames: '0.035'
    timeout_iterative_timer_based: '1.5'
  states: {}
- name: iNETS_PacketizedLink_RX_PHY_logger_0
  id: iNETS_PacketizedLink_RX_PHY_logger
  parameters:
    log_file_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/RX_PHY_Logger_events/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/RX_PHY_Logger_perposition/
    mode: defined
    simulation: 'False'
    station_code: sta_code
  states: {}
- name: iNETS_PacketizedLink_stop_wait_arq_0
  id: iNETS_PacketizedLink_stop_wait_arq
  parameters:
    ack_timeout: '90e-3'
    conf_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Stop_Wait_ARQ/
    initial_TX_RF_gain: '17'
    initial_rx_beam_index: init_rx_beam
    initial_tx_beam_index: init_tx_beam
    max_mtu_size: max_mtu_size
    max_retries: '2'
    partner_station_code: partner_sta_code
    send_only_when_trained: 'True'
    station_code: sta_code
    tx_mcs: '0'
    tx_scrambler_seed: scrambler_seed
    use_ack: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: import_3
  id: import
  parameters:
    imports: import ieee802_11
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '100'
    port: '52002'
    type: UDP_SERVER
  states: {}
- name: phy_transceiver_rx_spi_28g_0
  id: phy_transceiver_rx_spi_28g
  parameters:
    baseband_derotation_volatility: '0.8'
    bb_freq: bb_freq
    detector_threshold: detector_threshold
    max_mtu_size: max_mtu_size
    rand_pad: rand_pad
    samp_rate: samp_rate
    sps: sps
    subdev_spec_RX: usrp_rx_subdev_spec
    time_per_angle: time_per_angle_sec
    usrp_rx_address: usrp_rx_address
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Payload Constellation after Carrier Sync"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6, 0, 2, 5
    name: '"RX Correlation"'
    size: '16000'
    srate: 1e6
    type: complex
    update_time: '0.04'
    ymax: '100'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 4,0,2,5
    name: '"RX Signal"'
    size: '16000'
    srate: 1e6
    type: complex
    update_time: '0.04'
    ymax: '3'
    ymin: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '2000000'
  states: {}

connections:
- [iNETS_BeamManager_beamsteering_protocol_0, out, iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_out, iNETS_BeamManager_beamsteering_protocol_0, in]
- [iNETS_PacketizedLink_stop_wait_arq_0, rx_phy_logger_out, iNETS_PacketizedLink_RX_PHY_logger_0, rx_logger_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_out, network_socket_pdu_0, pdus]
- [network_socket_pdu_0, pdus, iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_in]
- [phy_transceiver_rx_spi_28g_0, '0', qtgui_time_sink_x_2, '0']
- [phy_transceiver_rx_spi_28g_0, '1', qtgui_const_sink_x_0, '0']
- [phy_transceiver_rx_spi_28g_0, '2', qtgui_time_sink_x_1, '0']
- [phy_transceiver_rx_spi_28g_0, RX PHY out, iNETS_PacketizedLink_stop_wait_arq_0, phy_in]
- [phy_transceiver_rx_spi_28g_0, SNR out, iNETS_PacketizedLink_stop_wait_arq_0, snr_in]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
