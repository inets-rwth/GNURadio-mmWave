options:
  parameters:
    author: Niklas Beckmann, Berk Acikgoez, Aleksandar Ichkov, Aron Schott
    copyright: iNETS - RWTH
    generate_options: qt_gui
    id: Transceiver_Station_RX_SPI_28G
    output_language: python
    title: Transceiver Station RX SPI 28G
  states: {}

blocks:
- name: bb_freq
  id: variable
  parameters:
    value: 35e6
  states: {}
- name: beam_id
  id: variable_qtgui_chooser
  parameters:
    label: Choose Fixed TX Beam
    labels: '[" Omni beam", "Beam 1", "Beam 2", "Beam 3", "Beam 4", "Beam 5", "Beam 6", "Beam 7", "Beam 8", "Beam 9", "Beam 10", "Beam 11", "Beam 12", "Beam 13", "Beam 14", "Beam 15", "Beam 16", "Beam 17", "Beam 18", "Beam 19", "Beam 20", "Beam 21"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21]'
    type: real
    value: '0'
  states: {state: disabled}
- name: detector_threshold
  id: variable
  parameters:
    value: '60'
  states: {}
- name: evk_serial
  id: variable
  parameters:
    comment: replace this with the serial number of your EVK device
    value: '"SNSP210071"'
  states: {}
- name: evk_trx_freq
  id: variable
  parameters:
    value: 27.44e9
  states: {}
- name: header_format
  id: variable
  parameters:
    value: iNETS_PHYHeader.phy_header().formatter()
  states: {}
- name: init_rx_beam
  id: variable
  parameters:
    value: '0'
  states: {}
- name: init_tx_beam
  id: variable
  parameters:
    value: '11'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: max_mtu_size
  id: variable
  parameters:
    value: '800'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: partner_sta_code
  id: variable
  parameters:
    value: '11'
  states: {}
- name: rand_pad
  id: variable
  parameters:
    value: '20'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '111'
  states: {}
- name: spi_sleep_sec
  id: variable
  parameters:
    value: '15'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sta_code
  id: variable
  parameters:
    value: '12'
  states: {}
- name: sweeping
  id: variable_qtgui_chooser
  parameters:
    label: Choose Beam Sweeping Type
    label0: Fixed TX beam
    label1: Full TX beam sweep
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'True'
  states: {}
- name: time_per_angle_sec
  id: variable
  parameters:
    value: '1.7'
  states: {}
- name: usrp_rx_address
  id: variable
  parameters:
    comment: replace this with the IP address of your USRP
    value: '"addr=192.168.20.2"'
  states: {}
- name: usrp_rx_subdev_spec
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GUI data handling',   # will show up in GRC\n            in_sig=None,\n            out_sig=[np.short, np.short, np.single]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('message_in'))\n        self.message_port_register_in(pmt.intern('snr_message_in'))\n\n        self.set_msg_handler(pmt.intern('message_in'), self.handle_msg)\n        self.set_msg_handler(pmt.intern('snr_message_in'), self.handle_snr_msg)\n\n        self.rx_beam_id = 0\n        self.tx_beam_id = 0\n        self.best_beam = 0\n        self.last_rssi = 0\n        self.last_preamble_snr = 0\n        self.preamble_rss = 0\n        self.mcs = 0\n\n        self.lastTime = time.time()\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = self.rx_beam_id\n        output_items[1][:] = self.tx_beam_id\n        #output_items[2][:] = self.best_beam\n        #output_items[2][:] = self.last_rssi\n        output_items[2][:] = self.last_preamble_snr\n        #output_items[2][:] = self.preamble_rss\n\n        return len(output_items[0])\n\n    def handle_msg(self, msg):\n\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"rx_beam_id\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"rx_beam_id\"), pmt.PMT_NIL)\n            if pmt.to_float(r) < 22:\n                self.rx_beam_id = pmt.to_float(r)\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"tx_beam_id\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"tx_beam_id\"), pmt.PMT_NIL)\n            if pmt.to_float(r) < 22:\n                self.tx_beam_id = pmt.to_float(r)\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"best_beam\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"best_beam\"), pmt.PMT_NIL)\n            self.best_beam = pmt.to_float(r)\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"last_rssi\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"last_rssi\"), pmt.PMT_NIL)\n            self.last_rssi = pmt.to_float(r)\n        #if pmt.dict_has_key(msg, pmt.string_to_symbol(\"last_preamble_snr\")):\n        #    r = pmt.dict_ref(msg, pmt.string_to_symbol(\"last_preamble_snr\"), pmt.PMT_NIL)\n        #    self.last_preamble_snr = pmt.to_float(r)\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"preamble_rss\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"preamble_rss\"), pmt.PMT_NIL)\n            self.preamble_rss = pmt.to_float(r)\n\n    def handle_snr_msg(self, msg):\n\n        meta = pmt.to_python(pmt.car(msg))\n\n        snr = meta[\"snr\"]\n        #print('SNR: ', snr, type(snr))\n\n        self.last_preamble_snr = snr\n\n\n"
  states: {state: disabled}
- name: iNETS_BeamManager_beamsteering_protocol_0
  id: iNETS_BeamManager_beamsteering_protocol
  parameters:
    beam_interval: '0.03'
    beamsteering_algorithm: '2'
    custom_beambook_suffix: '"_iNETS"'
    experimental_setup_comment: ''
    fixed_beam: init_rx_beam
    fixed_beam_backup_link_backup_beam_id: '21'
    fixed_beam_backup_link_beam_switch_message_retrans_no: '1'
    fixed_beam_backup_link_data_state_duration: '2.0'
    fixed_beam_backup_link_default_beam_id: '11'
    fixed_beam_backup_link_distance: '3.0'
    fixed_beam_backup_link_report_state_duration: '1.0'
    log_config_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Beamsteering_Protocol_events_configs/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Beamsteering_Protocol_persector/
    retrain_RSSI_threshold: '15'
    single_training_for_TX_and_RX: 'False'
    start_training: 'True'
    station_code: sta_code
    station_type: '1'
    sweeping: 'True'
    timeout_PLS: '0.2'
    timeout_PLS_timer_based: '0.03'
    timeout_PLS_timer_based_receive_SSW_frames: '0.03'
    timeout_RSSI_value_interval: '1.2'
    timeout_SLS: '0.2'
    timeout_SLS_timer_based: '0.24'
    timeout_SLS_timer_based_receive_SSW_frames: '0.065'
    timeout_history_search: '0.2'
    timeout_history_search_receive_SSW_frames: '0.8'
    timeout_iterative: '0.1'
    timeout_iterative_search_timer_based_receive_SSW_frames: '0.035'
    timeout_iterative_timer_based: '1.5'
  states: {}
- name: iNETS_PacketizedLink_RX_PHY_logger_0
  id: iNETS_PacketizedLink_RX_PHY_logger
  parameters:
    log_file_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/RX_PHY_Logger_events/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/RX_PHY_Logger_perposition/
    mode: defined
    simulation: 'False'
    station_code: sta_code
  states: {}
- name: iNETS_PacketizedLink_stop_wait_arq_0
  id: iNETS_PacketizedLink_stop_wait_arq
  parameters:
    ack_timeout: '90e-3'
    conf_parent_dir: /home/inets/Workspace/GNURadio_logs/RX_SPI_28G/Stop_Wait_ARQ/
    initial_TX_RF_gain: '17'
    initial_rx_beam_index: init_rx_beam
    initial_tx_beam_index: init_tx_beam
    max_mtu_size: max_mtu_size
    max_retries: '2'
    partner_station_code: partner_sta_code
    send_only_when_trained: 'True'
    station_code: sta_code
    tx_mcs: '0'
    tx_scrambler_seed: scrambler_seed
    use_ack: 'True'
  states: {}
- name: iNETS_SIVERSControl_evk02001_init_rx_0
  id: iNETS_SIVERSControl_evk02001_init_rx
  parameters:
    custom_beambook_suffix: '"_iNETS"'
    do_lo_leakage_cal: 'False'
    evkplatform_type: MB1
    initial_RX_RF_gain: '238'
    initial_RX_vga_1_2_gain: '115'
    initial_TX_BF_gain: '153'
    initial_TX_RF_gain: '17'
    initial_rx_beam_index: init_rx_beam
    initial_tx_beam_index: init_tx_beam
    sleep_amount: spi_sleep_sec
    trx_frequency: evk_trx_freq
    unit_name: evk_serial
    version_num: '202111231800'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: import_3
  id: import
  parameters:
    imports: import ieee802_11
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '100'
    port: '52002'
    type: UDP_SERVER
  states: {}
- name: phy_transceiver_rx_spi_28g_0
  id: phy_transceiver_rx_spi_28g
  parameters:
    baseband_derotation_volatility: '0.8'
    bb_freq: bb_freq
    detector_threshold: detector_threshold
    max_mtu_size: max_mtu_size
    rand_pad: rand_pad
    samp_rate: samp_rate
    sps: sps
    subdev_spec_RX: usrp_rx_subdev_spec
    time_per_angle: time_per_angle_sec
    usrp_rx_address: usrp_rx_address
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Payload Constellation after Carrier Sync"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,2,1,1
    name: '"SNR"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,1,1,1
    name: '"TX Beam ID"'
    type: short
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,1
    name: '"RX beam ID"'
    type: short
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6, 0, 2, 5
    name: '"RX Correlation"'
    size: '16000'
    srate: 1e6
    type: complex
    update_time: '0.04'
    ymax: '100'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 4,0,2,5
    name: '"RX Signal"'
    size: '16000'
    srate: 1e6
    type: complex
    update_time: '0.04'
    ymax: '3'
    ymin: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    type: intx
    value: '2000000'
  states: {}

connections:
- [epy_block_0, '0', qtgui_number_sink_2, '0']
- [epy_block_0, '1', qtgui_number_sink_1, '0']
- [epy_block_0, '2', qtgui_number_sink_0, '0']
- [iNETS_BeamManager_beamsteering_protocol_0, gui_out, epy_block_0, message_in]
- [iNETS_BeamManager_beamsteering_protocol_0, out, iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, antenna_array_control_out, iNETS_SIVERSControl_evk02001_init_rx_0, MAC_control_message_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_out, iNETS_BeamManager_beamsteering_protocol_0, in]
- [iNETS_PacketizedLink_stop_wait_arq_0, rx_phy_logger_out, iNETS_PacketizedLink_RX_PHY_logger_0, rx_logger_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_out, network_socket_pdu_0, pdus]
- [network_socket_pdu_0, pdus, iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_in]
- [phy_transceiver_rx_spi_28g_0, '0', qtgui_time_sink_x_2, '0']
- [phy_transceiver_rx_spi_28g_0, '1', qtgui_const_sink_x_0, '0']
- [phy_transceiver_rx_spi_28g_0, '2', qtgui_time_sink_x_1, '0']
- [phy_transceiver_rx_spi_28g_0, RX PHY out, iNETS_PacketizedLink_stop_wait_arq_0, phy_in]
- [phy_transceiver_rx_spi_28g_0, SNR out, iNETS_PacketizedLink_stop_wait_arq_0, snr_in]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
