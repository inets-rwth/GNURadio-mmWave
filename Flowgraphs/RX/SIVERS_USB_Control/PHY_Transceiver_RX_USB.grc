options:
  parameters:
    author: iNETS, Niklas
    category: '[iNETS_PacketizedLink]'
    copyright: iNETS - RWTH
    generate_options: hb
    id: phy_transceiver_rx_usb
    output_language: python
    title: Tranceiver PHY Level - RX USB
  states: {}

blocks:
- name: header_format
  id: variable
  parameters:
    value: iNETS_PHYHeader.phy_header().formatter()
  states: {}
- name: phy_CEF_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: phy_STF_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: phy_header_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '111'
  states: {}
- name: RX_SC_PHY_USB_0
  id: RX_SC_PHY_USB
  parameters:
    header_format: header_format
    max_mtu_size: max_mtu_size
    mu: baseband_derotation_volatility
    padding: rand_pad
    phy_STF_constellation: phy_STF_constellation
    phy_header_constellation: phy_header_constellation
    samp_rate: samp_rate
    scrambler_seed: scrambler_seed
    sps: sps
    threshold: detector_threshold
  states: {}
- name: baseband_derotation_volatility
  id: parameter
  parameters:
    label: Baseband Derotation Volatility
    value: '0.8'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    value: 35e6
  states: {}
- name: detector_threshold
  id: parameter
  parameters:
    label: Preamble Detection Threshold
    value: '60'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: max_mtu_size
  id: parameter
  parameters:
    label: Max MTU Size
    value: '800'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: RX Constellation before Carrier Sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: RX Constellation after Carrier Sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: SNR out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: RX PHY out
    type: message
  states: {}
- name: pad_sink_6
  id: pad_sink
  parameters:
    label: RX Correlation
    type: complex
  states: {}
- name: rand_pad
  id: parameter
  parameters:
    label: Random Padding
    value: '50'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '4'
  states: {}
- name: subdev_spec_RX
  id: parameter
  parameters:
    label: Subdevice Specification RX
    value: '"A:0"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: bb_freq
    comment: |-
      go on here with rx single carrier PHY
      and so on...
    dc_offs_enb0: disabled
    dev_addr: usrp_rx_address
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: disabled
    samp_rate: samp_rate
    sd_spec0: subdev_spec_RX
    sync: pc_clock
    type: fc32
  states: {}
- name: usrp_rx_address
  id: parameter
  parameters:
    label: USRP RX Address
    value: '"addr=192.168.10.2"'
  states: {}

connections:
- [RX_SC_PHY_USB_0, '0', pad_sink_0, '0']
- [RX_SC_PHY_USB_0, '1', pad_sink_3, '0']
- [RX_SC_PHY_USB_0, '2', pad_sink_6, '0']
- [RX_SC_PHY_USB_0, MAC Frame out, pad_sink_5, in]
- [RX_SC_PHY_USB_0, SNR out, pad_sink_4, in]
- [uhd_usrp_source_0, '0', RX_SC_PHY_USB_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
