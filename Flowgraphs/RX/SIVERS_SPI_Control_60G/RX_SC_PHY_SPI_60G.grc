options:
  parameters:
    author: iNETS
    category: '[iNETS_PacketizedLink]'
    copyright: iNETS
    generate_options: hb
    id: RX_SC_PHY_SPI_60G
    output_language: python
    title: RX Single Carrier PHY - SPI 60G
  states: {}

blocks:
- name: Golay_a_128
  id: variable
  parameters:
    value: 1,1,0,0,0,0,0,0,0,1,0,1,1,0,0,1,1,1,0,0,1,1,1,1,0,1,0,1,0,1,1,0,0,0,1,1,1,1,1,1,1,0,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,1,0,1,0,1,1,0,1,1,0,0,0,0,0,0,0,1,0,1,1,0,0,1,1,1,0,0,1,1,1,1,0,1,0,1,0,1,1,0,1,1,0,0,0,0,0,0,0,1,0,1,1,0,0,1,0,0,1,1,0,0,0,0,1,0,1,0,1,0,0,1
  states: {}
- name: diff_preamble_128
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: Golay_a_128
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    value: 369.8e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: phy_header_constellation.bits_per_symbol()
    l: '1'
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '6'
    mask: '0x91'
    reset_tag_key: '"packet_len"'
    seed: scrambler_seed
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: phy_header_constellation
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.01'
    msg_nsamples: '100'
    type: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: gnuradio.filter.firdes.root_raised_cosine(32,32*sps,1.0,0.8,32*11*sps)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: evk_set_beams_tt_RX_SPI_60G_0
  id: evk_set_beams_tt_RX_SPI_60G
  parameters:
    bb_freq: bb_freq
    samp_rate: samp_rate
    sps: sps
    time_per_angle: time_per_angle
    usrp_rx_address: usrp_rx_address
    usrp_rx_subdev_spec: usrp_rx_subdev_spec
  states: {}
- name: header_format
  id: parameter
  parameters:
    label: Header Format
    value: '0'
  states: {}
- name: iNETS_PacketizedLink_baseband_derotation_0
  id: iNETS_PacketizedLink_baseband_derotation
  parameters:
    constellation: phy_header_constellation
    mu: mu
  states: {}
- name: iNETS_PacketizedLink_baseband_derotation_tagged_stream_0
  id: iNETS_PacketizedLink_baseband_derotation_tagged_stream
  parameters:
    mu: mu
  states: {}
- name: iNETS_PacketizedLink_constellation_decoder_tagged_stream_0
  id: iNETS_PacketizedLink_constellation_decoder_tagged_stream
  parameters:
    mcstagname: '"mcs"'
  states: {}
- name: iNETS_PacketizedLink_estimate_dBm_ff_0
  id: iNETS_PacketizedLink_estimate_dBm_ff
  parameters:
    N: '300'
    alpha: '0.01'
    sps: sps
  states: {}
- name: iNETS_PacketizedLink_evm_biased_bpsk_0
  id: iNETS_PacketizedLink_evm_biased_bpsk
  parameters:
    number_of_header_samples: 64*8
  states: {}
- name: iNETS_PacketizedLink_frame_sync_cc_0
  id: iNETS_PacketizedLink_frame_sync_cc
  parameters:
    alpha: '0.001'
    detection_threshold: threshold
    len_tag_key: '"packet_len"'
    preamble: diff_preamble_128
    preamble_constellation: phy_STF_constellation
  states: {}
- name: iNETS_PacketizedLink_multiply_length_tag_tagged_stream_0
  id: iNETS_PacketizedLink_multiply_length_tag_tagged_stream
  parameters:
    lengthtagname: '"packet_len"'
    mcstagname: '"mcs"'
  states: {}
- name: iNETS_PacketizedLink_packet_header_parser_0
  id: iNETS_PacketizedLink_packet_header_parser
  parameters:
    header_formatter: header_format
    print_warnings: 'True'
  states: {}
- name: iNETS_PacketizedLink_phase_freq_correction_0
  id: iNETS_PacketizedLink_phase_freq_correction
  parameters:
    num_preamble_samples: len(preamble)//phy_header_constellation.bits_per_symbol()
  states: {}
- name: iNETS_PacketizedLink_phase_freq_correction_1
  id: iNETS_PacketizedLink_phase_freq_correction
  parameters:
    num_preamble_samples: int((len(preamble)+8)/phy_header_constellation.bits_per_symbol())
  states: {}
- name: iNETS_PacketizedLink_phy_agc_0
  id: iNETS_PacketizedLink_phy_agc
  parameters:
    attack_rate: '0.01'
    decay_rate: '20'
    gain: '0.01'
    max_gain: '350'
    reference: '1.0'
  states: {}
- name: iNETS_PacketizedLink_phy_header_payload_demux_0
  id: iNETS_PacketizedLink_phy_header_payload_demux
  parameters:
    guard_interval: '0'
    header_len: '8'
    header_padding: '0'
    length_tag_key: packet_len
    mcs_tag_key: mcs
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: '["rss"]'
    symbols_per_header_byte: '8'
    timing_tag_key: rx_time
    trigger_tag_key: '""'
    type: complex
  states: {}
- name: iNETS_PacketizedLink_repack_bits_tagged_stream_0
  id: iNETS_PacketizedLink_repack_bits_tagged_stream
  parameters:
    align_output: 'False'
    endianness: gr.GR_MSB_FIRST
    len_tag_key: '"packet_len"'
    mcs_tag_key: '"mcs"'
    mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio, ieee802_11
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: max_mtu_size
  id: parameter
  parameters:
    label: Max MTU Size
    value: '800'
  states: {}
- name: mu
  id: parameter
  parameters:
    label: Baseband Derotation Volatility
    type: eng_float
    value: '0.6'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: RX Constellation before Carrier Sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: RX Constellation after Carrier Sync
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: SNR out
    type: message
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: MAC Frame out
    type: message
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: Correlation
    type: complex
  states: {}
- name: padding
  id: parameter
  parameters:
    label: Random Padding
    value: '0'
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: phy_STF_constellation
  id: parameter
  parameters:
    label: STF Field Modulation
    value: digital.constellation_bpsk().base()
  states: {}
- name: phy_header_constellation
  id: parameter
  parameters:
    label: PHY Header Modulation
    value: digital.constellation_bpsk().base()
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}
- name: scrambler_seed
  id: parameter
  parameters:
    label: Scrambler Seed
    value: '0x6f'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: SPS
    type: intx
    value: '4'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Preamble Detector Threshold
    type: eng_float
    value: '60'
  states: {}
- name: time_per_angle
  id: parameter
  parameters:
    label: Time Per Angle (s)
    type: eng_float
    value: '1.7'
  states: {}
- name: usrp_rx_address
  id: parameter
  parameters:
    label: USRP RX Address
    value: '"addr=192.168.10.2"'
  states: {}
- name: usrp_rx_subdev_spec
  id: parameter
  parameters:
    label: USRP RX Subdev Spec
    value: '"A:0"'
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', iNETS_PacketizedLink_packet_header_parser_0, '0']
- [digital_additive_scrambler_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, pad_sink_2, in]
- [digital_symbol_sync_xx_0, '0', iNETS_PacketizedLink_frame_sync_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_0, '0']
- [evk_set_beams_tt_RX_SPI_60G_0, '0', iNETS_PacketizedLink_estimate_dBm_ff_0, '0']
- [iNETS_PacketizedLink_baseband_derotation_0, '0', iNETS_PacketizedLink_evm_biased_bpsk_0, '0']
- [iNETS_PacketizedLink_baseband_derotation_tagged_stream_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [iNETS_PacketizedLink_baseband_derotation_tagged_stream_0, '0', iNETS_PacketizedLink_constellation_decoder_tagged_stream_0, '0']
- [iNETS_PacketizedLink_baseband_derotation_tagged_stream_0, '0', pad_sink_1, '0']
- [iNETS_PacketizedLink_constellation_decoder_tagged_stream_0, '0', iNETS_PacketizedLink_repack_bits_tagged_stream_0, '0']
- [iNETS_PacketizedLink_estimate_dBm_ff_0, '0', iNETS_PacketizedLink_phy_agc_0, '0']
- [iNETS_PacketizedLink_evm_biased_bpsk_0, '0', digital_constellation_decoder_cb_0, '0']
- [iNETS_PacketizedLink_frame_sync_cc_0, '0', iNETS_PacketizedLink_phy_header_payload_demux_0, '0']
- [iNETS_PacketizedLink_frame_sync_cc_0, '1', pad_sink_4, '0']
- [iNETS_PacketizedLink_frame_sync_cc_0, '2', iNETS_PacketizedLink_phy_header_payload_demux_0, '1']
- [iNETS_PacketizedLink_multiply_length_tag_tagged_stream_0, '0', iNETS_PacketizedLink_phase_freq_correction_1, '0']
- [iNETS_PacketizedLink_packet_header_parser_0, header_data, iNETS_PacketizedLink_phy_header_payload_demux_0, header_data]
- [iNETS_PacketizedLink_phase_freq_correction_0, '0', iNETS_PacketizedLink_baseband_derotation_0, '0']
- [iNETS_PacketizedLink_phase_freq_correction_1, '0', iNETS_PacketizedLink_baseband_derotation_tagged_stream_0, '0']
- [iNETS_PacketizedLink_phy_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [iNETS_PacketizedLink_phy_agc_0, '1', blocks_null_sink_0, '0']
- [iNETS_PacketizedLink_phy_header_payload_demux_0, '0', iNETS_PacketizedLink_phase_freq_correction_0, '0']
- [iNETS_PacketizedLink_phy_header_payload_demux_0, '1', iNETS_PacketizedLink_multiply_length_tag_tagged_stream_0, '0']
- [iNETS_PacketizedLink_repack_bits_tagged_stream_0, '0', digital_additive_scrambler_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, pad_sink_3, in]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
