options:
  parameters:
    author: Berk
    category: '[iNETS_SIVERSControl]'
    copyright: iNETS
    generate_options: hb
    id: evk_set_beams_tt_RX_SPI_60G
    output_language: python
    title: Set Beams and TT for EVK - RX - SPI 60G
  states: {}

blocks:
- name: bb_freq
  id: parameter
  parameters:
    label: Carrier Frequency
    value: 369.8e6
  states: {}
- name: iNETS_SIVERSControl_evk_set_beams_tt_RX_0
  id: iNETS_SIVERSControl_evk_set_beams_tt_RX
  parameters:
    beam_indices: 0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21
    evkplatform_type: MB1
    sps: sps
    time_per_angle: time_per_angle
    use_spi: 'True'
  states: {}
- name: iNETS_SIVERSControl_evk_standalone_SPI_manager_0
  id: iNETS_SIVERSControl_evk_standalone_SPI_manager
  parameters:
    SPI_CLK_DIV: '24'
    SPI_CLK_PIN: '0'
    SPI_CS_PIN: '3'
    SPI_GPIO_PORT: GPIO0
    SPI_SDI_PIN: '2'
    SPI_SDO_PIN: '1'
    antenna_array_model: EVK06002
    usrp_obj: uhd_usrp_source_0
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}
- name: time_per_angle
  id: parameter
  parameters:
    label: Time Per Angle (s)
    type: eng_float
    value: '1.7'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: bb_freq
    clock_rate: 250e6
    comment: |-
      go on here with rx single carrier PHY
      and so on...
    dc_offs_enb0: disabled
    dev_addr: usrp_rx_address
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: disabled
    samp_rate: samp_rate
    sd_spec0: usrp_rx_subdev_spec
    sync: pc_clock
    type: fc32
  states: {}
- name: usrp_rx_address
  id: parameter
  parameters:
    label: USRP RX Address
    value: '"addr=192.168.10.2"'
  states: {}
- name: usrp_rx_subdev_spec
  id: parameter
  parameters:
    label: USRP RX Subdev Spec
    value: '"A:0"'
  states: {}

connections:
- [iNETS_SIVERSControl_evk_set_beams_tt_RX_0, '0', pad_sink_0, '0']
- [iNETS_SIVERSControl_evk_set_beams_tt_RX_0, spi_manager_out, iNETS_SIVERSControl_evk_standalone_SPI_manager_0, index_in]
- [iNETS_SIVERSControl_evk_standalone_SPI_manager_0, index_out, iNETS_SIVERSControl_evk_set_beams_tt_RX_0, spi_manager_in]
- [uhd_usrp_source_0, '0', iNETS_SIVERSControl_evk_set_beams_tt_RX_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-29-g0ef8fdea
