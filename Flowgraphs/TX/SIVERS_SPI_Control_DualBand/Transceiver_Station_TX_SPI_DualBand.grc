options:
  parameters:
    author: Niklas Beckmann, Berk Acikgoez, Aleksandar Ichkov, Aron Schott
    copyright: iNets - RWTH
    generate_options: qt_gui
    id: Transceiver_Station_TX_SPI_dualband
    output_language: python
    title: Transceiver Station TX SPI Dual Band
  states: {}

blocks:
- name: bb_freq_28
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: bb_freq_60
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: beam_id
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,2
    label: Choose Fixed TX Beam
    labels: '["Omni Beam", "Omni Beam", "Beam 1","Beam 1","Beam 2", "Beam 2", "Beam 3","Beam 3", "Beam 4","Beam 4", "Beam 5","Beam 5", "Beam 6","Beam 6", "Beam 7", "Beam 7","Beam 8", "Beam 8","Beam 9", "Beam 9","Beam 10", "Beam 10", "Beam 11", "Beam 11","Beam 12", "Beam 12","Beam 13", "Beam 13","Beam 14", "Beam 14", "Beam 15", "Beam 15","Beam 16", "Beam 16","Beam 17", "Beam 17","Beam 18", "Beam 18","Beam 19", "Beam 19","Beam 20", "Beam 20", "Beam 21", "Beam 21"]'
    num_opts: '0'
    options: '[0,0,1,1,2, 2, 3, 3, 4, 4, 5, 5, 6,6, 7,7,8, 8,9, 9,10, 10,11, 11,12, 12,13, 13, 14, 14,15,15, 16,16, 17,17, 18, 18, 19,19, 20,20, 21,21]'
    type: real
    value: '11'
  states: {}
- name: detector_threshold
  id: variable
  parameters:
    value: '60'
  states: {}
- name: evk02001_init_tx_rf_gain
  id: variable
  parameters:
    value: '0x44'
  states: {}
- name: evk02001_serial
  id: variable
  parameters:
    comment: replace this with the serial number of your EVK device
    value: '"SNSP210157"'
  states: {}
- name: evk02001_trx_freq
  id: variable
  parameters:
    value: 27.45e9
  states: {}
- name: evk06002_init_tx_rf_gain
  id: variable
  parameters:
    value: '0xFF'
  states: {}
- name: evk06002_serial
  id: variable
  parameters:
    comment: replace this with the serial number of your EVK device
    value: '"T582304971"'
  states: {}
- name: evk06002_trx_freq
  id: variable
  parameters:
    value: 58.32e9
  states: {}
- name: header_format
  id: variable
  parameters:
    value: iNETS_PHYHeader.phy_header().formatter()
  states: {}
- name: init_rx_beam
  id: variable
  parameters:
    value: '0'
  states: {}
- name: init_tx_beam
  id: variable
  parameters:
    value: '11'
  states: {}
- name: max_mtu_size
  id: variable
  parameters:
    value: '800'
  states: {}
- name: partner_sta_code
  id: variable
  parameters:
    value: '22'
  states: {}
- name: rand_pad
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '111'
  states: {}
- name: spi_sleep_sec
  id: variable
  parameters:
    value: '15'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sta_code
  id: variable
  parameters:
    value: '21'
  states: {}
- name: sweeping
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: Choose Beam Sweeping Type
    label0: Fixed TX beam
    label1: Full TX beam sweep
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'True'
  states: {}
- name: usrp_tx_address
  id: variable
  parameters:
    comment: replace this with the IP address of your USRP
    value: '"addr=192.168.10.2"'
  states: {}
- name: usrp_tx_subdev_spec
  id: variable
  parameters:
    value: '"A:0 B:1"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='GUI data handling',   # will show up in GRC\n            in_sig=None,\n            out_sig=[np.single]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('message_in'))\n        self.image_portName = 'image_portName'\n        self.set_msg_handler(pmt.intern('message_in'), self.handle_msg)\n        self.message_port_register_out(pmt.intern(self.image_portName))\n        self.tx_beam_id = 0\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = self.tx_beam_id\n\n\n        return len(output_items[0])\n\n    def handle_msg(self, msg):\n        if pmt.dict_has_key(msg, pmt.string_to_symbol(\"tx_beam_id\")):\n            r = pmt.dict_ref(msg, pmt.string_to_symbol(\"tx_beam_id\"), pmt.PMT_NIL)\n            if pmt.to_long(r) < 22:\n                self.tx_beam_id = pmt.to_long(r)\n                PMT_beam = pmt.string_to_symbol('/home/inets/Workspace/beam_plots/beamId_' + str(self.tx_beam_id) + '.png')\n                PMT_msg = pmt.cons(pmt.from_bool(True), PMT_beam)\n                self.message_port_pub(pmt.intern(self.image_portName), PMT_msg)\n\n"
  states: {}
- name: iNETS_BeamManager_beamsteering_protocol_0
  id: iNETS_BeamManager_beamsteering_protocol
  parameters:
    beam_interval: '0.065'
    beamsteering_algorithm: '2'
    custom_beambook_suffix: '"_iNETS"'
    experimental_setup_comment: ''
    fixed_beam: init_tx_beam
    fixed_beam_backup_link_backup_beam_id: '1'
    fixed_beam_backup_link_beam_switch_message_retrans_no: '1'
    fixed_beam_backup_link_data_state_duration: '2.0'
    fixed_beam_backup_link_default_beam_id: '11'
    fixed_beam_backup_link_distance: '3.0'
    fixed_beam_backup_link_report_state_duration: '1.0'
    log_config_parent_dir: /home/inets/Workspace/GNURadio_logs/TX_USB/Beamsteering_Protocol_events_configs/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/TX_USB/Beamsteering_Protocol_persector/
    retrain_RSSI_threshold: '15'
    single_training_for_TX_and_RX: 'False'
    start_training: 'True'
    station_code: sta_code
    station_type: '0'
    sweeping: 'True'
    timeout_PLS: '0.2'
    timeout_PLS_timer_based: '0.035'
    timeout_PLS_timer_based_receive_SSW_frames: '0.065'
    timeout_RSSI_value_interval: '1.2'
    timeout_SLS: '0.2'
    timeout_SLS_timer_based: '0.28'
    timeout_SLS_timer_based_receive_SSW_frames: '0.065'
    timeout_history_search: '0.2'
    timeout_history_search_receive_SSW_frames: '0.8'
    timeout_iterative: '0.1'
    timeout_iterative_search_timer_based_receive_SSW_frames: '0.035'
    timeout_iterative_timer_based: '1.5'
  states: {}
- name: iNETS_PacketizedLink_RX_PHY_logger_0
  id: iNETS_PacketizedLink_RX_PHY_logger
  parameters:
    log_file_parent_dir: /home/inets/Workspace/GNURadio_logs/TX_USB/RX_PHY_Logger_events/
    log_per_sector: 'False'
    log_per_sector_parent_dir: /home/inets/Workspace/GNURadio_logs/TX_USB/RX_PHY_Logger_perposition/
    mode: defined
    simulation: 'True'
    station_code: sta_code
  states: {state: disabled}
- name: iNETS_PacketizedLink_stop_wait_arq_0
  id: iNETS_PacketizedLink_stop_wait_arq
  parameters:
    ack_timeout: '90e-3'
    conf_parent_dir: /home/inets/Workspace/GNURadio_logs/TX_USB/Stop_Wait_ARQ/
    initial_TX_RF_gain: evk02001_init_tx_rf_gain
    initial_rx_beam_index: init_rx_beam
    initial_tx_beam_index: init_tx_beam
    max_mtu_size: max_mtu_size
    max_retries: '2'
    partner_station_code: partner_sta_code
    send_only_when_trained: 'True'
    station_code: sta_code
    tx_mcs: '0'
    tx_scrambler_seed: scrambler_seed
    use_ack: 'False'
  states: {}
- name: iNETS_SIVERSControl_evk02001_init_tx_0
  id: iNETS_SIVERSControl_evk02001_init_tx
  parameters:
    custom_beambook_suffix: '"_iNETS"'
    do_lo_leakage_cal: 'False'
    evkplatform_type: MB1
    initial_RX_RF_gain: '238'
    initial_RX_vga_1_2_gain: '115'
    initial_TX_BF_gain: '153'
    initial_TX_RF_gain: evk02001_init_tx_rf_gain
    initial_rx_beam_index: init_rx_beam
    initial_tx_beam_index: init_tx_beam
    sleep_amount: spi_sleep_sec
    trx_frequency: evk02001_trx_freq
    unit_name: evk02001_serial
    version_num: '202111231800'
  states: {state: disabled}
- name: iNETS_SIVERSControl_evk06002_init_tx_0
  id: iNETS_SIVERSControl_evk06002_init_tx
  parameters:
    custom_beambook_suffix: '"_iNETS"'
    do_lo_leakage_cal: 'False'
    evkplatform_type: MB1
    initial_RX_RF_gain: '238'
    initial_RX_vga_1_2_gain: '115'
    initial_TX_RF_gain: evk06002_init_tx_rf_gain
    initial_tx_beam_index: init_tx_beam + 21
    sleep_amount: spi_sleep_sec
    trx_frequency: evk06002_trx_freq
    unit_name: evk06002_serial
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_3
  id: import
  parameters:
    imports: import ieee802_11
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '100'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: phy_transceiver_tx_spi_dualband_0
  id: phy_transceiver_tx_spi_dualband
  parameters:
    baseband_derotation_volatility: '0.8'
    bb_freq_28: bb_freq_28
    bb_freq_60: bb_freq_60
    detector_threshold: detector_threshold
    init_beam: init_tx_beam
    max_mtu_size: max_mtu_size
    rand_pad: rand_pad
    samp_rate: samp_rate
    sps: sps
    subdev_spec_TX: usrp_tx_subdev_spec
    usrp_tx_address: usrp_tx_address
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,3,4,3
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: /home/inets/Workspace/beam_plots/beamId_1.png
    gui_hint: 0,2,4,1
    scaleImage: 'True'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,1
    label1: '"Beam ID"'
    name: '"TX codebook sweeping"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0,2,6
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, image_portName, qtgui_graphicitem_0, filename]
- [iNETS_BeamManager_beamsteering_protocol_0, gui_out, epy_block_0, message_in]
- [iNETS_BeamManager_beamsteering_protocol_0, out, iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, antenna_array_control_out, iNETS_SIVERSControl_evk02001_init_tx_0, MAC_control_message_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, antenna_array_control_out, iNETS_SIVERSControl_evk06002_init_tx_0, MAC_control_message_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, beamforming_protocol_out, iNETS_BeamManager_beamsteering_protocol_0, in]
- [iNETS_PacketizedLink_stop_wait_arq_0, phy_out, phy_transceiver_tx_spi_dualband_0, TX PHY in]
- [iNETS_PacketizedLink_stop_wait_arq_0, rx_phy_logger_out, iNETS_PacketizedLink_RX_PHY_logger_0, rx_logger_in]
- [iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_out, network_socket_pdu_0, pdus]
- [network_socket_pdu_0, pdus, iNETS_PacketizedLink_stop_wait_arq_0, udp_socket_in]
- [phy_transceiver_tx_spi_dualband_0, '0', qtgui_time_sink_x_0, '0']
- [phy_transceiver_tx_spi_dualband_0, '1', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
