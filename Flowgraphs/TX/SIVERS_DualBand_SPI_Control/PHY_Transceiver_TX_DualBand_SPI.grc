options:
  parameters:
    author: inets, Niklas, Berk, Aleksandar, Aron
    category: '[iNETS_PacketizedLink]'
    copyright: inets RWTH
    generate_options: hb
    id: phy_transceiver_tx_dualband_spi
    output_language: python
    title: Tranceiver PHY Level - TX Dual Band SPI
  states: {}

blocks:
- name: header_format
  id: variable
  parameters:
    value: iNETS_PHYHeader.phy_header().formatter()
  states: {}
- name: phy_CEF_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: phy_STF_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: phy_header_constellation
  id: variable
  parameters:
    value: gnuradio.digital.constellation_bpsk().base()
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '111'
  states: {}
- name: TX_SC_PHY_1
  id: TX_SC_PHY
  parameters:
    header_format: header_format
    max_mtu_size: max_mtu_size
    phy_CEF_constellation: phy_CEF_constellation
    phy_STF_constellation: phy_STF_constellation
    phy_header_constellation: phy_header_constellation
    rand_pad: rand_pad
    scrambler_seed: scrambler_seed
    sps: sps
  states: {}
- name: baseband_derotation_volatility
  id: parameter
  parameters:
    label: Baseband Derotation Volatility
    value: '0.8'
  states: {}
- name: bb_freq_28
  id: parameter
  parameters:
    label: Carrier Frequency (28G)
    value: 25e6
  states: {}
- name: bb_freq_60
  id: parameter
  parameters:
    label: Carrier Frequency (60G)
    value: 100e6
  states: {}
- name: detector_threshold
  id: parameter
  parameters:
    label: Preamble Detection Threshold
    value: '100'
  states: {}
- name: iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI_0
  id: iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI
  parameters:
    SPI_CLK_DIV: '24'
    SPI_CLK_PIN_28: '0'
    SPI_CLK_PIN_60: '11'
    SPI_CS_PIN_28: '3'
    SPI_CS_PIN_60: '8'
    SPI_GPIO_PORT: GPIO0
    SPI_SDI_PIN_28: '2'
    SPI_SDI_PIN_60: '9'
    SPI_SDO_PIN_28: '1'
    SPI_SDO_PIN_60: '10'
    beam_tag_name: tx_beam_id
    initial_beam_index: init_beam
    length_tag_name: packet_len
    usrp_obj: uhd_usrp_sink_0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_2
  id: import
  parameters:
    imports: from gnuradio import iNETS_PHYHeader
  states: {}
- name: init_beam
  id: parameter
  parameters:
    label: Initial Beam Index
    value: '0'
  states: {}
- name: max_mtu_size
  id: parameter
  parameters:
    label: Max MTU Size
    value: '800'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: TX Bursts
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: TX Constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: TX PHY in
    type: message
  states: {}
- name: rand_pad
  id: parameter
  parameters:
    label: Random Padding
    value: '50'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '4'
  states: {}
- name: subdev_spec_TX
  id: parameter
  parameters:
    label: Subdevice Specification TX
    value: '"A:0 B:1"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: bb_freq_28
    center_freq1: bb_freq_60
    clock_rate: 250e6
    dev_addr: usrp_tx_address
    gain0: '0'
    gain1: '0'
    len_tag_name: '"packet_len"'
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: subdev_spec_TX
    stream_chans: '[0,1]'
    sync: pc_clock
    type: fc32
  states: {}
- name: usrp_tx_address
  id: parameter
  parameters:
    label: USRP TX Address
    value: '"addr=192.168.100.46"'
  states: {}

connections:
- [TX_SC_PHY_1, '0', pad_sink_2, '0']
- [TX_SC_PHY_1, '1', iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI_0, '0']
- [iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI_0, '0', pad_sink_1, '0']
- [iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI_0, '0', uhd_usrp_sink_0, '0']
- [iNETS_SIVERSControl_evk_set_beams_TX_dual_SPI_0, '0', uhd_usrp_sink_0, '1']
- [pad_source_0, out, TX_SC_PHY_1, MAC frame in]

metadata:
  file_format: 1
  grc_version: 3.10.6.0
