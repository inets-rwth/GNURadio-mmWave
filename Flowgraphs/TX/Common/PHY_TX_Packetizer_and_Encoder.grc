options:
  parameters:
    author: iNETS
    category: '[iNETS_PacketizedLink]'
    copyright: iNETS - RWTH
    generate_options: hb
    id: PHY_TX_Packetizer_and_Encoder
    output_language: python
    title: TX Packetizer and Encoder
  states: {}

blocks:
- name: diff_preamble_128
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0,0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0,0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 0][0:128]'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: padding
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: padding
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: phy_STF_constellation.bits_per_symbol()
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_3
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: phy_header_constellation.bits_per_symbol()
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_4
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: padding
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: STF
    len_tag_key: '"packet_len"'
    packet_len: '16'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_3
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Random Padding
    len_tag_key: '"packet_len"'
    packet_len: padding
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: MUX
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Join all fields of PHY frame:
      -Preamble:
      	-STF
      	-CEF
      -PHY Header
      -PHY Payload
      -TRN-T/R
      +Random Pre- and Post-Padding
    lengthtagname: '"packet_len"'
    minoutbuf: (max_mtu_size+16+64+2*padding)*8*7
    ninputs: '5'
    tag_preserve_head_pos: '3'
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: diff_preamble_128
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '6'
    mask: '0x91'
    reset_tag_key: '"packet_len"'
    seed: scrambler_seed
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Always BPSK modulated
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: STF, variable modulation
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: phy_STF_constellation.points()
  states: {}
- name: digital_chunks_to_symbols_xx_3
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Header, normally BPSK
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: phy_header_constellation.points()
  states: {}
- name: digital_chunks_to_symbols_xx_4
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Always BPSK modulated
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_format
    len_tag_key: '"packet_len"'
  states: {}
- name: header_format
  id: parameter
  parameters:
    label: Header Format
    value: '0'
  states: {}
- name: iNETS_PacketizedLink_chunks_to_symbols_tagged_stream_0
  id: iNETS_PacketizedLink_chunks_to_symbols_tagged_stream
  parameters:
    comment: |-
      Payload, variable modulation
      (including TRN-T)
    mcstagname: '"mcs"'
    minoutbuf: max_mtu_size*8*6
  states: {}
- name: iNETS_PacketizedLink_repack_bits_tagged_stream_0
  id: iNETS_PacketizedLink_repack_bits_tagged_stream
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    len_tag_key: '"packet_len"'
    mcs_tag_key: '"mcs"'
    mode: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import blocks
  states: {}
- name: max_mtu_size
  id: parameter
  parameters:
    label: Max MTU Size
    value: '400'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Packet Stream Out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: MAC Frame in
    type: message
  states: {}
- name: padding
  id: parameter
  parameters:
    label: Random Padding
    value: '0'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: phy_CEF_constellation
  id: parameter
  parameters:
    label: CEF Field Modulation
    value: digital.constellation_bpsk()
  states: {}
- name: phy_STF_constellation
  id: parameter
  parameters:
    label: STF Field Modulation
    value: digital.constellation_bpsk()
  states: {}
- name: phy_header_constellation
  id: parameter
  parameters:
    label: PHY Header Modulation
    value: digital.constellation_bpsk()
  states: {}
- name: scrambler_seed
  id: parameter
  parameters:
    label: Scrambler Seed
    value: '0x6f'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_1, '0', blocks_stream_to_tagged_stream_3, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_repack_bits_bb_3, '0', digital_chunks_to_symbols_xx_3, '0']
- [blocks_repack_bits_bb_4, '0', digital_chunks_to_symbols_xx_4, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_repack_bits_bb_1, '0']
- [blocks_stream_to_tagged_stream_3, '0', blocks_repack_bits_bb_4, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_debug_1, '0']
- [blocks_tagged_stream_mux_0, '0', pad_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_vector_source_x_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_additive_scrambler_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_additive_scrambler_bb_0, '0', iNETS_PacketizedLink_repack_bits_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_3, '0', blocks_tagged_stream_mux_0, '2']
- [digital_chunks_to_symbols_xx_4, '0', blocks_tagged_stream_mux_0, '4']
- [digital_packet_headergenerator_bb_0, '0', blocks_repack_bits_bb_3, '0']
- [iNETS_PacketizedLink_chunks_to_symbols_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '3']
- [iNETS_PacketizedLink_repack_bits_tagged_stream_0, '0', iNETS_PacketizedLink_chunks_to_symbols_tagged_stream_0, '0']
- [pad_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
