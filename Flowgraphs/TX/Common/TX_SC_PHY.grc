options:
  parameters:
    author: Niklas Beckmann
    category: '[iNETS_PacketizedLink]'
    copyright: iNETS - RWTH
    generate_options: hb
    id: TX_SC_PHY
    output_language: python
    title: TX SIngle Carrier PHY
  states: {}

blocks:
- name: PHY_TX_Packetizer_and_Encoder_0
  id: PHY_TX_Packetizer_and_Encoder
  parameters:
    header_format: header_format
    max_mtu_size: max_mtu_size
    padding: rand_pad
    phy_CEF_constellation: phy_CEF_constellation
    phy_STF_constellation: phy_STF_constellation
    phy_header_constellation: phy_header_constellation
    scrambler_seed: scrambler_seed
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    comment: Required since RRC filter up-samples
    lengthtagname: '"packet_len"'
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '100'
    pre_padding: '0'
    type: complex
    window: gnuradio.fft.window.rectangular(2048)
  states: {}
- name: header_format
  id: parameter
  parameters:
    label: Header Format
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio
  states: {}
- name: max_mtu_size
  id: parameter
  parameters:
    label: Max MTU Size
    value: '250'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: TX Constellation
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: PHY_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: MAC frame in
    type: message
  states: {}
- name: phy_CEF_constellation
  id: parameter
  parameters:
    label: CEF Field Modulation
    value: gnuradio.digital.constellation_bpsk()
  states: {}
- name: phy_STF_constellation
  id: parameter
  parameters:
    label: STF Field Modulation
    value: gnuradio.digital.constellation_bpsk()
  states: {}
- name: phy_header_constellation
  id: parameter
  parameters:
    label: PHY Header Modulation
    value: gnuradio.digital.constellation_bpsk()
  states: {}
- name: rand_pad
  id: parameter
  parameters:
    label: Random Padding
    value: '64'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.8'
    gain: sps
    interp: sps
    ntaps: 11*sps
    samp_rate: sps
    sym_rate: '1.0'
    type: interp_fir_filter_ccf
  states: {}
- name: scrambler_seed
  id: parameter
  parameters:
    label: Scrambler Seed
    value: '0x6f'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: intx
    value: '4'
  states: {}

connections:
- [PHY_TX_Packetizer_and_Encoder_0, '0', pad_sink_0, '0']
- [PHY_TX_Packetizer_and_Encoder_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [pad_source_0, out, PHY_TX_Packetizer_and_Encoder_0, MAC Frame in]
- [root_raised_cosine_filter_0, '0', blocks_tagged_stream_multiply_length_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
